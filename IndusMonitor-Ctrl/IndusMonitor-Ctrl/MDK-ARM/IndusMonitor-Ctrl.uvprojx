# Keil uVision project IndusMonitor-Ctrl.uvprojx, settings and files
target IndusMonitor-Ctrl (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: smarthome +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Work;../hardware;../LittleFS;../tft;../LVGL;../LVGL/src;../LVGL/examples/porting;../LVGL/MyGUI;../LVGL/MySymbol;../wifi;../data;../user;../modbus;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src;../Middlewares/Third_Party/FatFs/src/drivers
  asm include: ../Core/Inc;..\Work
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x64000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c iwdg.c rtc.c sdio.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_ll_sdmmc.c stm32f1xx_hal_sd.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group wifi
    ../wifi/: esp8266.c esp8266.h core_json.c core_json.h
  group User
    ../user/: device.c device.h sensor.c sensor.h motor.c motor.h
  group Work
    ../Work/: HTU21D.c HTU21D.h alarm.c alarm.h
  group hardware
    ../hardware/: myi2c.c myi2c.h myspi.c myspi.h myadc.c myadc .h key.c key.h rs485.c rs485.h
  group data
    ../data/: personal_Data.c personal_Data.h Public_Data.c Public_Data.h sd_data.c sd_data.h
  group modbus
    ../modbus/: modbus.c modbus.h modbus_crc.c modbus_crc.h
  group tft
    ../tft/: lcd.c lcd.h FONT.h GUI.c GUI.h
  group LVGL_MyGUI
    ../LVGL/MyGUI/: mygui.c mygui.h user.c user.h
  group MySymobl
    ../LVGL/MySymbol/: temp.c humd.c light.c smoke.c
  group LVGL_conf
    ../LVGL/: lvgl.h lv_conf.h
  group LVGL_porting
    ../LVGL/examples/porting/: lv_port_disp.c lv_port_disp.h lv_port_fs.c lv_port_fs.h lv_port_indev.c lv_port_indev.h
  group LVGL_src
    ../LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../LVGL/src/draw/arm2d/: lv_gpu_arm2d.c
    ../LVGL/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../LVGL/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../LVGL/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../LVGL/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../LVGL/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../LVGL/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../LVGL/src/extra/layouts/flex/: lv_flex.c
    ../LVGL/src/extra/layouts/grid/: lv_grid.c
    ../LVGL/src/extra/libs/bmp/: lv_bmp.c
    ../LVGL/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../LVGL/src/extra/libs/freetype/: lv_freetype.c
    ../LVGL/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../LVGL/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../LVGL/src/extra/libs/png/: lodepng.c lv_png.c
    ../LVGL/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../LVGL/src/extra/libs/rlottie/: lv_rlottie.c
    ../LVGL/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../LVGL/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../LVGL/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../LVGL/src/extra/others/gridnav/: lv_gridnav.c
    ../LVGL/src/extra/others/ime/: lv_ime_pinyin.c
    ../LVGL/src/extra/others/imgfont/: lv_imgfont.c
    ../LVGL/src/extra/others/monkey/: lv_monkey.c
    ../LVGL/src/extra/others/msg/: lv_msg.c
    ../LVGL/src/extra/others/snapshot/: lv_snapshot.c
    ../LVGL/src/extra/themes/basic/: lv_theme_basic.c
    ../LVGL/src/extra/themes/default/: lv_theme_default.c
    ../LVGL/src/extra/themes/mono/: lv_theme_mono.c
    ../LVGL/src/extra/widgets/animimg/: lv_animimg.c
    ../LVGL/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../LVGL/src/extra/widgets/chart/: lv_chart.c
    ../LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../LVGL/src/extra/widgets/keyboard/: lv_keyboard.c
    ../LVGL/src/extra/widgets/led/: lv_led.c
    ../LVGL/src/extra/widgets/list/: lv_list.c
    ../LVGL/src/extra/widgets/menu/: lv_menu.c
    ../LVGL/src/extra/widgets/meter/: lv_meter.c
    ../LVGL/src/extra/widgets/msgbox/: lv_msgbox.c
    ../LVGL/src/extra/widgets/span/: lv_span.c
    ../LVGL/src/extra/widgets/spinbox/: lv_spinbox.c
    ../LVGL/src/extra/widgets/spinner/: lv_spinner.c
    ../LVGL/src/extra/widgets/tabview/: lv_tabview.c
    ../LVGL/src/extra/widgets/tileview/: lv_tileview.c
    ../LVGL/src/extra/widgets/win/: lv_win.c
    ../LVGL/src/extra/: lv_extra.c
    ../LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../LVGL/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
software components: CMSIS:CORE 5.6.0
